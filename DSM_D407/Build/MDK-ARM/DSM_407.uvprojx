# Keil uVision project DSM_407.uvprojx, settings and files
target DSM_407_Debug (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: DSM_407 +hex
  c flags: Optim=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,ARM_MATH_CM4,__TARGET_FPU_VFP,__FPU_PRESENT=1U
  c include: ..\..\Inc;..\..\Src\SW_Framework;..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy;..\..\Middlewares\ST\STM32_Audio\Addons\PDM;..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\..\Middlewares\ST\STM32_USB_Device_Library\Class\AUDIO\Inc;..\..\Middlewares\Third_Party\FreeRTOS\Source\include;..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS;..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\Drivers\BSP\STM32F4-Discovery;..\..\Drivers\CMSIS\Include;..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\Src\Codec2\src\CMSIS;..\..\Src\MELPe\inc
  asm include: ..\..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\DSM_407.sct
  link misc: --diag_suppress=L6329
  group Drivers/STM32F4xx_HAL_Driver
    ../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_i2s.c stm32f4xx_hal_rng.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_i2c.c stm32f4xx_hal.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_crc.c stm32f4xx_hal_dma.c stm32f4xx_hal_rcc.c stm32f4xx_hal_pcd.c stm32f4xx_hal_i2s_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_pwr.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Drivers/BSP
    ../../Drivers/BSP/STM32F4-Discovery/: stm32f4_discovery.c stm32f4_discovery_audio.c nRF24L01.c nRF24L01func.c
    ../../Drivers/BSP/Components/cs43l22/: cs43l22.c
  group Middlewares/USB_Device_Library
    ../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ctlreq.c usbd_ioreq.c usbd_core.c
    ../../Middlewares/ST/STM32_USB_Device_Library/Class/AUDIO/Src/: usbd_audio.c
  group Middlewares/FreeRTOS
    ../../Middlewares/Third_Party/FreeRTOS/Source/: queue.c timers.c tasks.c croutine.c event_groups.c list.c
    ../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Application/MDK-ARM
    ../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
  group Application/User
    ../../Src/: main.c
    ../../Src/SW_Framework/: datatasks.c dataqueues.c HardFaultHandler.c
    ../../Src/DSM_Process/: processtask.c
  group Application/Lib
    ../../Middlewares/ST/STM32_Audio/Addons/PDM/: libPDMFilter_CM4F_Keil.lib pdm_filter.h
  group Application/HWConfig
    ../../Src/HW_Config/: usbd_conf.c i2c.c usb_device.c crc.c rng.c usbd_audio_if.c i2s.c usbd_desc.c stm32f4xx_hal_msp.c stm32f4xx_it.c dma.c gpio.c spi.c tim.c
  group Codecs/MELP
    ../../Src/MELP/: coeff.c dsp_sub.c fec_code.c fs_lib.c fsvq_cb.c lpc_lib.c main.c melp_ana.c melp_chn.c melp_sub.c melp_syn.c msvq_cb.c pit_lib.c vq_lib.c module.c
  group Codecs/CVSD
    ../../Src/CVSD/: cvsd_f32.c main.c module.c
  group Codecs/CODEC2
    ../../Src/Codec2/src/: codebook.c codebookd.c codebookdt.c codebookge.c codebookjvm.c codebookmel.c codebookres.c codebookvq.c codebookvqanssi.c codebooklspmelvq.c codec2.c interp.c lpc.c lsp.c nlp.c pack.c phase.c postfilter.c quantise.c sine.c main.c module.c
    ../../Src/Codec2/src/CMSIS/: math_ext.c
  group Codecs/MELPe
    ../../Src/MELPe/src/: classify.c coeff.c dsp_sub.c fec_code.c fft_lib.c fs_lib.c fsvq_cb.c global.c harm.c lpc_lib.c math_lib.c melp_ana.c melp_chn.c melp_sub.c melp_syn.c module.c msvq_cb.c npp.c pit_lib.c pitch.c postfilt.c qnt12.c qnt12_cb.c vq_lib.c
  group Codecs/A_u_law
    ../../Src/A_u_Law/: aulaw_q15.c main.c module.c
  group Codecs/Converters
    ../../Src/UpDownSamplers/: UpDown8_48_Q15.c UpDown8_48_F32.c UpDown16_48_F32.c RateSync.c
target DSM_407_Release (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: as above
  output: DSM_407 +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: as above
  c include: as above
  asm include: ..\..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\DSM_407.sct
  link misc: --diag_suppress=L6329
software components: CMSIS:CORE 4.1.0, CMSIS:DSP 1.4.5
